# Keil uVision project periodic-uplink-lpp.uvprojx, settings and files
target periodic-uplink-lpp-as923 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L072CZYx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00030000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: periodic-uplink-lpp-as923 +hex
  AfterMake: fromelf --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER STM32L072xx REGION_AS923 ACTIVE_REGION=LORAMAC_REGION_AS923 LORAMAC_CLASSB_ENABLED USE_RADIO_DEBUG
  c include: ..\..\..\..\src;..\..\..\..\src\apps\LoRaMac\periodic-uplink-lpp\B-L072Z-LRWAN1;..\..\..\..\src\apps\LoRaMac\common;..\..\..\..\src\apps\LoRaMac\common\LmHandler;..\..\..\..\src\apps\LoRaMac\common\LmHandler\packages;..\..\..\..\src\boards;..\..\..\..\src\boards\B-L072Z-LRWAN1;..\..\..\..\src\boards\B-L072Z-LRWAN1\cmsis;..\..\..\..\src\boards\mcu\stm32;..\..\..\..\src\boards\mcu\stm32\cmsis;..\..\..\..\src\boards\mcu\stm32\STM32L0xx_HAL_Driver\inc;..\..\..\..\src\apps\LoRaMac\common;..\..\..\..\src\mac;..\..\..\..\src\mac\region;..\..\..\..\src\peripherals;..\..\..\..\src\peripherals\soft-se;..\..\..\..\src\radio;..\..\..\..\src\system;..\..\..\..\src\system\crypto
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group apps
    ../../../../src/apps/LoRaMac/periodic-uplink-lpp/B-L072Z-LRWAN1/: main.c
  group apps\common
    ../../../../src/apps/LoRaMac/common/: CayenneLpp.c LmHandlerMsgDisplay.c NvmCtxMgmt.c
  group apps\common\LmHandler
    ../../../../src/apps/LoRaMac/common/LmHandler/: LmHandler.c
  group apps\common\LmHandler\packages
    ../../../../src/apps/LoRaMac/common/LmHandler/packages/: FragDecoder.c LmhpClockSync.c LmhpCompliance.c LmhpFragmentation.c LmhpRemoteMcastSetup.c
  group boards\B-L072Z-LRWAN1
    ../../../../src/boards/B-L072Z-LRWAN1/: board.c delay-board.c eeprom-board.c gpio-board.c lpm-board.c rtc-board.c spi-board.c sx1276-board.c uart-board.c
  group boards\B-L072Z-LRWAN1\cmsis
    ../../../../src/boards/B-L072Z-LRWAN1/cmsis/: system_stm32l0xx.c
    ../../../../src/boards/B-L072Z-LRWAN1/cmsis/arm-std/: startup_stm32l072xx.s
  group boards\B-L072Z-LRWAN1\STM32L0xx_HAL_Driver
    ../../../../src/boards/mcu/stm32/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
  group boards\mcu\stm32
    ../../../../src/boards/mcu/stm32/: sysIrqHandlers.c
    ../../../../src/boards/mcu/: utilities.c
  group mac
    ../../../../src/mac/: LoRaMac.c LoRaMacAdr.c LoRaMacClassB.c LoRaMacCommands.c LoRaMacConfirmQueue.c LoRaMacCrypto.c LoRaMacParser.c LoRaMacSerializer.c
  group mac\region
    ../../../../src/mac/region/: Region.c RegionAS923.c RegionAU915.c RegionBaseUS.c RegionCN470.c RegionCN779.c RegionCommon.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionRU864.c RegionUS915.c
  group peripherals\soft-se
    ../../../../src/peripherals/soft-se/: aes.c cmac.c soft-se.c soft-se-hal.c
  group radio
    ../../../../src/radio/sx1276/: sx1276.c
  group system
    ../../../../src/system/: delay.c eeprom.c fifo.c gpio.c nvmm.c systime.c timer.c uart.c
target periodic-uplink-lpp-au915 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L072CZYx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.1.0
  cpu: as above
  output: periodic-uplink-lpp-au915 +hex
  AfterMake: fromelf --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER STM32L072xx REGION_AU915 ACTIVE_REGION=LORAMAC_REGION_AU915 LORAMAC_CLASSB_ENABLED USE_RADIO_DEBUG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
target periodic-uplink-lpp-cn470 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L072CZYx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.1.0
  cpu: as above
  output: periodic-uplink-lpp-cn470 +hex
  AfterMake: fromelf --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER STM32L072xx REGION_CN470 ACTIVE_REGION=LORAMAC_REGION_CN470 LORAMAC_CLASSB_ENABLED USE_RADIO_DEBUG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
target periodic-uplink-lpp-cn779 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L072CZYx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.1.0
  cpu: as above
  output: periodic-uplink-lpp-cn779 +hex
  AfterMake: fromelf --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER STM32L072xx REGION_CN779 ACTIVE_REGION=LORAMAC_REGION_CN779 LORAMAC_CLASSB_ENABLED USE_RADIO_DEBUG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
target periodic-uplink-lpp-eu433 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L072CZYx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.1.0
  cpu: as above
  output: periodic-uplink-lpp-eu433 +hex
  AfterMake: fromelf --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER STM32L072xx REGION_EU433 ACTIVE_REGION=LORAMAC_REGION_EU433 LORAMAC_CLASSB_ENABLED USE_RADIO_DEBUG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
target periodic-uplink-lpp-eu868 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L072CZYx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.1.0
  cpu: as above
  output: periodic-uplink-lpp-eu868 +hex
  AfterMake: fromelf --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER STM32L072xx REGION_EU868 ACTIVE_REGION=LORAMAC_REGION_EU868 LORAMAC_CLASSB_ENABLED USE_RADIO_DEBUG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
target periodic-uplink-lpp-kr920 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L072CZYx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.1.0
  cpu: as above
  output: periodic-uplink-lpp-kr920 +hex
  AfterMake: fromelf --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER STM32L072xx REGION_KR920 ACTIVE_REGION=LORAMAC_REGION_KR920 LORAMAC_CLASSB_ENABLED USE_RADIO_DEBUG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
target periodic-uplink-lpp-in865 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L072CZYx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.1.0
  cpu: as above
  output: periodic-uplink-lpp-in865 +hex
  AfterMake: fromelf --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER STM32L072xx REGION_IN865 ACTIVE_REGION=LORAMAC_REGION_IN865 LORAMAC_CLASSB_ENABLED USE_RADIO_DEBUG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
target periodic-uplink-lpp-ru864 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L072CZYx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.1.0
  cpu: as above
  output: periodic-uplink-lpp-ru864 +hex
  AfterMake: fromelf --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER STM32L072xx REGION_RU864 ACTIVE_REGION=LORAMAC_REGION_RU864 LORAMAC_CLASSB_ENABLED USE_RADIO_DEBUG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
target periodic-uplink-lpp-us915 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L072CZYx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.1.0
  cpu: as above
  output: periodic-uplink-lpp-us915 +hex
  AfterMake: fromelf --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER STM32L072xx REGION_US915 ACTIVE_REGION=LORAMAC_REGION_US915 LORAMAC_CLASSB_ENABLED USE_RADIO_DEBUG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
